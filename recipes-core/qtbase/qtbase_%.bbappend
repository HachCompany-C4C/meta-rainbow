PACKAGECONFIG_append = "  accessibility tslib eglfs gles2 examples linuxfb"
